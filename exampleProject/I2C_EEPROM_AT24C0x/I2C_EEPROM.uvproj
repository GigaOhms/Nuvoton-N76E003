# Keil uVision project I2C_EEPROM.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: I2C_EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\LIB
  group Source
    ./Code/: I2C_EEPROM.c
    ../../LIB/: I2Ceeprom2.c I2Ceeprom2.h
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
