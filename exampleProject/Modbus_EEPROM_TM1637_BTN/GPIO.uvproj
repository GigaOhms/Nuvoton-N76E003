# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\LIB
  group Source Group 1
    ./Code/: GPIO.C
    ../../LIB/: avr.c avr.h I2Ceeprom.c I2Ceeprom.h ModbusRTU.c ModbusRTU.h TM1637.c TM1637.h
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
