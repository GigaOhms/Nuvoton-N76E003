# Keil uVision project main.uvproj, settings and files
target main (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\LIB
  group Source Group 1
    ./Code/: main.c
    ../../LIB/: I2Ceeprom.c I2Ceeprom.h ModbusRTU.c ModbusRTU.h TM1637.c TM1637.h GPIO.h GPIO.c
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
